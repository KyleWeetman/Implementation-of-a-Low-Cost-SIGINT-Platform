options:
  parameters:
    generate_options: qt_gui
    id: ReplayCapture
    output_language: python
    title: Replay Capture
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '315000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/lcy13vv/School/Capstone/Key Fobs/ChevySonic2013.dat
    repeat: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
